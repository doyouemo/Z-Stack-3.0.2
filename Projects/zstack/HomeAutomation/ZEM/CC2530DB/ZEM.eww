<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ZEM.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>ALL</name>
            <member>
                <project>ZEM</project>
                <configuration>CoordinatorEB</configuration>
            </member>
            <member>
                <project>ZEM</project>
                <configuration>RouterEB</configuration>
            </member>
            <member>
                <project>ZEM</project>
                <configuration>EndDeviceEB</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
